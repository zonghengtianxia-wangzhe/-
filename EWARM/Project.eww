<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\IPMI_STM32F205RCTx_V1.0.ewp</path>
  </project>
  <batchBuild />
</workspace>
